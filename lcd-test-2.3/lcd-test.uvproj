# Keil uVision project lcd-test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lcd-test +hex
  AfterMake: fromelf --bin ".\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: .\CMSIS;.\CMSIS\Include;.\Lib\inc;.\User
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./: startup_M051Series.s
    ./CMSIS/: system_M051Series.c
  group User
    ./User/: delay.c Lcd_Driver.c main.c GUI.c demo.c DS18B20.c DS1390.c Relay.c
  group Library
    ./Lib/src/: clk.c gpio.c retarget.c sys.c uart.c spi.c timer.c fmc.c
